# Keil uVision project 智能小车.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODAT2
  output: 智能小车 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\HARDWARE\1602;.\HARDWARE\OLED;.\HARDWARE;.\HARDWARE
  group user
    ./USER/: main.c
  group HARDWARE
    ./HARDWARE/: 1602_LCD.c Bluetooth.c motor.c sys.h Timer.c RGB.c delay.c
